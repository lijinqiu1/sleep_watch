# Keil uVision project sleep_watch.uvprojx, settings and files
target nrf51822_xxaa_s110 (256K) (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sleep_watch +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: BOARD_PCA10001 NRF51,DEBUG_NRF_USER, BLE_STACK_SUPPORT_REQD SPI_MASTER_1_ENABLE ADV_GENERAL
  c include: ..;..\Include;..\Include\app_common;..\Include\ble;..\Include\ble\ble_services;..\Include\s110;..\Include\sd_common;..\Include\serialization\connectivity;..\Include\ble\device_manager;..\Include\sdk;..\User\Inc
  asm define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10001 DEBUG_NRF_USER SPI_MASTER_1_ENABLE ENABLE_DEBUG_LOG_SUPPORT ADV_BOND
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x25000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Source Code
    ../User/Src/: main.c lis3dh_driver.c queue.c pwm.c adc.c led.c battery.c
  group Services
    ../User/Src/: ble_nus.c
    ../Source/ble/ble_services/: ble_srv_common.c
  group Libraries
    ../Source/ble/: ble_advdata.c ble_conn_params.c
    ../Source/sd_common/: softdevice_handler.c
    ../Source/simple_uart/: simple_uart.c
    ../Source/app_common/: app_timer.c pstorage.c app_gpiote.c app_trace.c
    ../Source/spi_master/: spi_master.c
    ../User/Src/: calender.c
    ../Source/ble/device_manager/: device_manager_peripheral.c
software components: CMSIS:CORE 5.0.2, Device:Startup 8.14.1
